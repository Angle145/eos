# Keil uVision project eOS-Cortex_M0.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: eOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\eOS;..\Driver;..\User;..\eOS\plugin;..\CoreLib\CORE;..\CoreLib\STM32F03x_FWLib\inc;..\CoreLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c
    ../CoreLib/: stm32f0xx_it.c
  group Driver
    ../Driver/: led.c led.h usart.c usart.h
  group CoreLib
    ../CoreLib/CORE/: startup_stm32f0xx.s
    ../CoreLib/STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c
    ../CoreLib/: system_stm32f0xx.c
  group eOS
    ../eOS/: eos_main.c eos.c eos.h eos_port1.asm eos_port2.c
    ../eOS/plugin/: eos_plugin_shell.c eos_plugin_shell.h
